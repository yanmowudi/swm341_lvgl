# Keil uVision project SWM341_StdPeriph_Driver.uvprojx, settings and files
target SWM341_disp1 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.17.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\CSL\CMSIS\CoreSupport;..\CSL\CMSIS\DeviceSupport;..\CSL\SWM341_StdPeriph_Driver;..\BSP;.
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
  group APP
    ./: main.c
  group BSP
    ../BSP/: dev_gt9x.c dev_rgb.c dev_sdio.c dev_sdram.c dev_sfc.c dev_systick.c dev_uart.c
  group CSL\StdPD
    ../CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_can.c SWM341_cordic.c SWM341_crc.c SWM341_dac.c SWM341_div.c SWM341_dma.c SWM341_dma2d.c SWM341_exti.c SWM341_flash.c SWM341_gpio.c SWM341_i2c.c SWM341_jpeg.c SWM341_lcd.c SWM341_port.c SWM341_pwm.c SWM341_qei.c SWM341_rtc.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_spi.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_usbh.c SWM341_wdt.c
  group CSL\CMSIS
    ../CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group porting
    ./lvgl/examples/porting/: lv_port_indev.c lv_port_disp1.c lv_port_disp2_1.c lv_port_disp2_2.c lv_port_disp3.c
  group core
    ./lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group draw
    ./lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group extra
    ./lvgl/src/extra/layouts/flex/: lv_flex.c
    ./lvgl/src/extra/layouts/grid/: lv_grid.c
    ./lvgl/src/extra/libs/bmp/: lv_bmp.c
    ./lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./lvgl/src/extra/libs/freetype/: lv_freetype.c
    ./lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
    ./lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ./lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ./lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ./lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ./lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ./lvgl/src/extra/others/monkey/: lv_monkey.c
    ./lvgl/src/extra/others/msg/: lv_msg.c
    ./lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ./lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./lvgl/src/extra/themes/default/: lv_theme_default.c
    ./lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./lvgl/src/extra/widgets/chart/: lv_chart.c
    ./lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./lvgl/src/extra/widgets/led/: lv_led.c
    ./lvgl/src/extra/widgets/list/: lv_list.c
    ./lvgl/src/extra/widgets/menu/: lv_menu.c
    ./lvgl/src/extra/widgets/meter/: lv_meter.c
    ./lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./lvgl/src/extra/widgets/span/: lv_span.c
    ./lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./lvgl/src/extra/widgets/win/: lv_win.c
    ./lvgl/src/extra/: lv_extra.c
  group font
    ./lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group hal
    ./lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group misc
    ./lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group widgets
    ./lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group examples
    ./lvgl/demos/benchmark/: lv_demo_benchmark.c
    ./lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ./lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ./lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ./lvgl/demos/widgets/: lv_demo_widgets.c
    ./lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
target SWM341_disp2_1 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.17.0
  cpu: as above
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
target SWM341_disp2_2 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.17.0
  cpu: as above
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
target SWM341_disp3 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.17.0
  cpu: as above
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
