# Keil uVision project SWM341_StdPeriph_Driver.uvprojx, settings and files
target SWM341_disp1 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c include: ..\CSL\CMSIS\CoreSupport;..\CSL\CMSIS\DeviceSupport;..\CSL\SWM341_StdPeriph_Driver;..\BSP;.
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
  group APP
    ./: main.c
  group BSP
    ../BSP/: dev_gt9x.c dev_rgb.c dev_sdio.c dev_sdram.c dev_sfc.c dev_systick.c dev_uart.c
  group CSL\StdPD
    ../CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_can.c SWM341_cordic.c SWM341_crc.c SWM341_dac.c SWM341_div.c SWM341_dma.c SWM341_dma2d.c SWM341_exti.c SWM341_flash.c SWM341_gpio.c SWM341_i2c.c SWM341_jpeg.c SWM341_lcd.c SWM341_port.c SWM341_pwm.c SWM341_qei.c SWM341_rtc.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_spi.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_usbh.c SWM341_wdt.c
  group CSL\CMSIS
    ../CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ../CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
  group lv_porting
    ./lvgl/examples/porting/: lv_port_disp1.c lv_port_disp2_1.c lv_port_disp2_2.c lv_port_disp3.c lv_port_indev.c lv_port_fs.c
  group lv_core
    ./lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ./lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ./lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lv_gpu
    ./lvgl/src/lv_gpu/: lv_gpu_swm341_dma2d.c
  group lv_hal
    ./lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ./lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_themes
    ./lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
  group lv_widgets
    ./lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group lv_examples
    ./lv_examples/src/lv_demo_benchmark/: lv_demo_benchmark.c
    ./lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
    ./lv_examples/src/assets/: img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
    ./lv_examples/src/lv_demo_music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ./lv_examples/src/lv_demo_music/assets/: img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_right.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_3.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_4.c img_lv_demo_music_list_border.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_top.c lv_demo_music_font_16_bold.c
target SWM341_disp2_1 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.0
  cpu: as above
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
target SWM341_disp2_2 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.0
  cpu: as above
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
target SWM341_disp3 (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.0.0
  cpu: as above
  output: SWM341_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=5 OneElfS=1 v6Lang=3 v6LangP=3
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: ..\BSP\SWM341_stdperiph_lib.sct
